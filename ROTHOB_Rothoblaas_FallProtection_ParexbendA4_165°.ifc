Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: ebeb2df6-2f09-4052-8835-cae1e0ec08e5, NumberOfSaves: 1], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Planimetria di default]
File name: ROTHOB_Rothoblaas_FallProtection_ParexbendA4_165°.ifc
Time: 2025-05-06T17:41:17
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 m
Vincoli - Quota altimetrica: 0 m
Quote - Altezza di calcolo: 0 m
Dati identità - Nome: 0_Rothoblaas; Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello

# IfcBuildingElementProxy: Attrezzature speciali : ROTHOB_Rothoblaas_FallProtection_ParexbendA4 : 71x116x565mm
In: 0_Rothoblaas
Type - ElementType: FALL_ARRESTER_DEVICES; PredefinedType: USERDEFINED; Material: ROTHOB_Rothoblaas_StainlessSteelAISI316
Type - Generale - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_FallProtection_ParexbendA4; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-27 71 21; OmniClassTitle: Fall Arrest Systems; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fall-protection-system/anchor-lines/patrol-on-wall; Revision: 001; UniClass2015Code: Pr_40_70_75_29; UniClass2015Title: Fall arrester devices; UniClass2015Version: Products v1.37; Version: 002
Type - Vincoli - Prospetto di default: 1.2192 m
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_StainlessSteelAISI316
Type - Quote - DextPipe: 0.012 m; DintPipe: 0.009 m; Height_H: 0.11629 m; Length_L: 0.565 m; Ltot: 0.545 m; OffsetPipeAxis: 0.06541 m; Radius: 0.18 m; Width_B: 0.07141 m
Type - Dati identità - Descrizione: External pass-through angle bracket for façades adjustable 105°-165°; Nome del tipo: 71x116x565mm; Numero OmniClass: 23.27.71.21; Produttore: info@rothoblaas.com
Type - Altro - Categoria: Attrezzature speciali; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_70_75_29 - Fall arrester devices; CodePerformance: Safety system; Color: Silver; Constituents: n/a; DurationUnit: Years; ExpectedLife: n/a; Features: Wall-mounted lifeline; Finish: Stainless steel; Grade: n/a; GTIN: 8033224485416; Material: AISI 316 stainless steel grade 1.4401; MinWeight: 0.7 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: PAREXBENDA4; ModelReference: n/a; Name: Lifeline angle element; Nome famiglia: ROTHOB_Rothoblaas_FallProtection_ParexbendA4; NominalHeight: 0.11629 m; NominalLength: 0.565 m; NominalWidth: 0.07141 m; ReferenceStandard: EN 795:2012 C | CEN/TS 16415:2013 | UNI 11578:2015 C | AS/NZS 1891.2:2001 | AS/NZS 1891.4:2009 | CSA Z259.16; ReplacementCost: n/a; Shape: Three-dimensional; Size: 71x116x565 mm; SustainabilityPerformance: BVB Accepted; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Lifeline angle element; Category: Pr_40_70_75_29 - Fall arrester devices
Type - Pset_ProvisionForVoid - Shape: Three-dimensional
Pset_BuildingElementProxyCommon - Reference: 71x116x565mm; sets with these values: 2
Visibilità - 90°Pipe: no; BendingPipe: yes; StraightPipe: no
Vincoli - Host: Piano di riferimento : REF; Quota altimetrica da livello: 0 m
Fasi - Fase di creazione: Stato di Progetto
Quote - A: 15 deg; Angle: 15 deg; Area: 0.0555572 m2; BendingAngle: 165 deg; La: 0.0471239 m; Ls: 0.248938 m; Volume: 0.000027813 m3
Altro - Famiglia: ROTHOB_Rothoblaas_FallProtection_ParexbendA4; Famiglia e tipo: ROTHOB_Rothoblaas_FallProtection_ParexbendA4: 71x116x565mm; ID tipo: 187483; Tipo: 71x116x565mm
