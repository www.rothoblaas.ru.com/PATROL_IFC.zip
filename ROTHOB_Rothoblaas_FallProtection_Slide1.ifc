Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 807bac58-898e-44cb-afcb-5be07f887c0b, NumberOfSaves: 4], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Planimetria di default]
File name: ROTHOB_Rothoblaas_FallProtection_Slide1.ifc
Time: 2025-05-08T16:18:34
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 m
Vincoli - Quota altimetrica: 0 m
Quote - Altezza di calcolo: 0 m
Dati identità - Nome: 0_Rothoblaas; Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello

# IfcBuildingElementProxy: Attrezzature speciali : ROTHOB_Rothoblaas_FallProtection_Slide1 : SLIDE1_30x60x60mm
In: 0_Rothoblaas
Type - ElementType: FALL_ARRESTER_DEVICES; PredefinedType: USERDEFINED; Material: ROTHOB_Rothoblaas_StainlessSteelAISI304
Type - Generale - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_FallProtection_Slide1; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-27 71 21; OmniClassTitle: Fall Arrest Systems; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fall-protection-system/anchor-lines/patrol; Revision: 001; UniClass2015Code: Pr_40_70_75_29; UniClass2015Title: Fall arrester devices; UniClass2015Version: Products v1.37; Version: 003
Type - Vincoli - Prospetto di default: 1.2192 m
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_StainlessSteelAISI304
Type - Quote - Height_H: 0.06 m; Length_L: 0.06 m; Width_B: 0.03 m
Type - Dati identità - Descrizione: Removable sliding device; Nome del tipo: SLIDE1_30x60x60mm; Numero OmniClass: 23.27.71.21; Produttore: info@rothoblaas.com
Type - Altro - Categoria: Attrezzature speciali; AccessibilityPerformance: n/a; AssetType: Movable; Category: Pr_40_70_75_29 - Fall arrester devices; CodePerformance: Safety system; Color: Silver; Constituents: Carabiner; DurationUnit: Years; ExpectedLife: n/a; Features: Horizontal lifeline; Finish: n/a; Grade: n/a; GTIN: 8058776175707; Material: AISI 304 stainless steel grade 1.4301; MinWeight: 0.4 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: SLIDE1; ModelReference: n/a; Name: Removable sliding device; Nome famiglia: ROTHOB_Rothoblaas_FallProtection_Slide1; NominalHeight: 0.06 m; NominalLength: 0 m; NominalWidth: 0.03 m; ReferenceStandard: EN 795:2012 C | CEN/TS 16415:2013 | UNI 11578:2015 C | AS/NZS 1891.2:2001 | AS/NZS 1891.4:2009 | CSA Z259.16; ReplacementCost: n/a; Shape: Three-dimensional; Size: 30x60x60 mm; SustainabilityPerformance: BVB Accepted; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Removable sliding device; Category: Pr_40_70_75_29 - Fall arrester devices
Type - Pset_ProvisionForVoid - Shape: Three-dimensional
Material: ROTHOB_Rothoblaas_StainlessSteelAISI304, ROTHOB_Rothoblaas_StainlessSteel
Pset_BuildingElementProxyCommon - Reference: SLIDE1_30x60x60mm; sets with these values: 2
Vincoli - Host: Livello : 0_Rothoblaas; Livello: 0_Rothoblaas; Livello abaco: 0_Rothoblaas; Quota altimetrica da livello: 0 m
Fasi - Fase di creazione: Stato di Progetto
Quote - Volume: 0.0000721541 m3
Altro - Famiglia: ROTHOB_Rothoblaas_FallProtection_Slide1; Famiglia e tipo: ROTHOB_Rothoblaas_FallProtection_Slide1: SLIDE1_30x60x60mm; ID tipo: 240142; Tipo: SLIDE1_30x60x60mm
